# Keil uVision project template.uvprojx, settings and files
target JingXiaxianmu (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: JingXiaxianmu
  AfterMake: fromelf --bin !L --output JingXiaxianmu.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32L496xx
  c include: .;..\SDK\rt-thread\include;.;applications;..\SDK\rt-thread\libcpu\arm\common;..\SDK\rt-thread\libcpu\arm\cortex-m4;..\SDK\rt-thread\components\drivers\include;..\SDK\rt-thread\components\drivers\include;..\SDK\rt-thread\components\drivers\include;..\SDK\rt-thread\components\finsh;..\SDK\libraries\CMSIS\Device\ST\STM32L4xx\Include;..\SDK\libraries\CMSIS\Include;..\SDK\libraries\STM32L4xx_HAL_Driver\inc;..\SDK\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.1
