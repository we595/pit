# Keil uVision project project.uvprojx, settings and files
target JingXiaxianmu (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: JingXiaxianmu
  AfterMake: fromelf --bin !L --output JingXiaxianmu.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32L496xx, USE_HAL_DRIVER
  c include: .;..\SDK\rt-thread\include;.;applications;..\SDK\rt-thread\libcpu\arm\common;..\SDK\rt-thread\libcpu\arm\cortex-m4;..\SDK\rt-thread\components\drivers\include;..\SDK\rt-thread\components\drivers\include;..\SDK\rt-thread\components\drivers\include;..\SDK\rt-thread\components\finsh;..\SDK\libraries\CMSIS\Device\ST\STM32L4xx\Include;..\SDK\libraries\CMSIS\Include;..\SDK\libraries\STM32L4xx_HAL_Driver\inc;..\SDK\drivers;.\UserSrc;.\UserInc;.\HardwareSrc;.\HardwareInc;..\SDK\rt-thread\components\drivers\include\ipc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Kernel
    ../SDK/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group cpu
    ../SDK/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../SDK/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../SDK/rt-thread/components/drivers/misc/: pin.c
    ../SDK/rt-thread/components/drivers/serial/: serial.c
    ../SDK/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../SDK/rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32L4xx_HAL_Driver
    ../SDK/libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../SDK/libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l496xx.s
    ../SDK/libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_dac.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c
    ../SDK/libraries/STM32L4xx_HAL_Driver/inc/: stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dac.h
  group Drivers
    ../SDK/drivers/: board.c drv_clock.c drv_gpio.c drv_usart.c stm32l4xx_hal_conf.h board.h
  group UserSrc
    ./UserSrc/: Init.c Define.c ModBus.c
    ./: ReadMe.txt
  group UserInc
    ./UserInc/: Init.h Define.h ModBus.h
  group HardwareSrc
    ./HardwareSrc/: Motor.c RS485.c Pressure.c
  group HardwareInc
    ./HardwareInc/: Motor.h RS485.h Pressure.h
software components: CMSIS:CORE 5.0.1
